LR_IROM1 0x08000000 0x0007F800  {
  ER_IROM1 0x08000000 0x0007F800  {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_IRAM1 0x20000000 0x00010000  {
    .ANY (+RW +ZI)
  }
}
