# Keil uVision project PressureFixture_STM32F103ZET6.uvprojx, settings and files
target PressureFixture_STM32F103ZET6 ()
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000,0x10000) IROM(0x8000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: PressureFixture_STM32F103ZET6 +hex
  c include: ..\Core\Inc;..\App\Inc;..\BSP\Inc;..\USB_DEVICE\App;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc
  group Core
    ../Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group App
    ../App/Src/: app_keys.c app_pcba_uart.c app_power.c app_pressure.c app_protocol.c app_state_machine.c app_valves.c usb_msc_app.c
  group BSP
    ../BSP/Src/: board_pins.c bsp_w25q128.c lt768_basic.c lt768_port.c
  group USB_DEVICE
    ../USB_DEVICE/App/: storage_w25q_msc.c
