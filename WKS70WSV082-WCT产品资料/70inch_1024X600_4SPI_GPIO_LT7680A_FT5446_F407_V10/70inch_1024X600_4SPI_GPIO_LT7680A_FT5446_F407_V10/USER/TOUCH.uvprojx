# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: 70inch_1024X600_4SPI_LT7680A_FT5446U_F407_V10 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\IF_PORT;..\HARDWARE\LT768_Lib;..\HARDWARE\LT768;..\HARDWARE\LT768_Demo;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IF_PORT/: if_port.c
    ../HARDWARE/LT768_Lib/: LT768_Lib.c
    ../HARDWARE/LT768/: LT768.c
    ../HARDWARE/LT768_Demo/: LT768_Demo.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c ft5206.c gt5688.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group README
    ../: readme.txt
